# Keil uVision project D16_RX.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: D16_RX +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\CORE;..\DRIVER;..\LIB\inc;..\USER;..\HARDWARE;..\FUNCTION
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CORE
    ../CORE/: startup_stm32f030.s
  group DRIVER
    ../DRIVER/: spi.c timer.c adc.c cc2500_frsky_x.c rx_cc2500.c rx.c
  group HARDWARE
    ../HARDWARE/: key.c led.c
  group LIB
    ../LIB/src/: stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c stm32f0xx_adc.c
  group USER
    ../USER/: main.c stm32f0xx_it.c system_stm32f0xx.c
  group FUNCTION
    ../FUNCTION/: delay.c flash.c function.c iwdog.c system.c
    ../DRIVER/: sbus.c
